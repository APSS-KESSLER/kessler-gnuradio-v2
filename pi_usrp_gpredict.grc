options:
  parameters:
    author: orbops
    generate_options: qt_gui
    id: pi_usrp_gpredict
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://172.24.103.124:50241
    timeout: '100'
  states: {}

connections:
- [gpredict_doppler_0, freq, blocks_message_debug_0, print]
- [gpredict_doppler_0, freq, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
