options:
  parameters:
    generate_options: qt_gui
    id: ES_RX_Custom
    output_language: python
    title: ES_Custom_Rx
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_0_0
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010101001111110'
    tagname: preamble + syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '208'
    sensitivity: '1.0'
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"After Demod"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"After Correlation"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '43'
    sync: '"1010101001111110"'
    threshold: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 435e6
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_uchar_to_float_0_1_0_1, '0', qtgui_time_sink_x_0_1_1, '0']
- [blocks_uchar_to_float_0_1_0_1_0, '0', qtgui_time_sink_x_0_1_1_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0_1_0_1_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0_1_0_1, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [satellites_sync_to_pdu_packed_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_sync_to_pdu_packed_0, out, network_socket_pdu_0_1, pdus]
- [soapy_rtlsdr_source_0, '0', digital_gfsk_demod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
