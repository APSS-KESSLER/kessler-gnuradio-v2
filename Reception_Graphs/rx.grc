options:
  parameters:
    author: Orb Ops APSS
    generate_options: qt_gui
    id: textrecording1
    output_language: python
    title: Rx
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_0_0
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Lenovo\Downloads\debug3.txt
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_demod_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 438e6
    fftsize: '1024'
    name: '"RAW RF INPUT"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 438e6
    name: '"FINAL"'
    type: msg_float
  states: {}
- name: satellites_endurosat_deframer_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud
    iq: 'True'
    options: '"--deviation 2400 --use_agc"'
    samp_rate: baud*2
    subaudio: 'False'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 438E6
    freq_correction: '97.5'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', satellites_endurosat_deframer_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_endurosat_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_endurosat_deframer_0, out, network_socket_pdu_0, pdus]
- [satellites_endurosat_deframer_0, out, qtgui_waterfall_sink_x_2, in]
- [satellites_fsk_demodulator_0, '0', blocks_float_to_uchar_0, '0']
- [satellites_fsk_demodulator_0, '0', blocks_uchar_to_float_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_endurosat_deframer_0, '0']
- [soapy_rtlsdr_source_0, '0', digital_gfsk_demod_1, '0']
- [soapy_rtlsdr_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
