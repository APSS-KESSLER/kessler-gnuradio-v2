options:
  parameters:
    generate_options: qt_gui
    id: rx_new
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: TED_gain
  id: variable_qtgui_range
  parameters:
    label: TED_gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud_rate) / 2
  states: {}
- name: frequency_correction
  id: variable_qtgui_range
  parameters:
    label: frequency correction
    start: '0'
    step: '1'
    stop: '100'
    value: '7'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate//Decimation)/(2*math.pi*freq_deviation)
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: ((samp_rate // Decimation) // baud_rate)
    ted_gain: TED_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr

      class pdu_second_byte_filter(gr.basic_block):
          """
          pass PDUs only if second byte == 0xFE
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_second_byte_filter",
                  in_sig=None,
                  out_sig=None
              )

              # Message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # Expect (metadata . u8vector)
              if not pmt.is_pair(msg):
                  return

              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  return

              vec = pmt.u8vector_elements(data)

              # Need at least 2 bytes
              if len(vec) < 2:
                  return

              # Check second byte
              if vec[1] == 0xFE:
                  # Pass through unchanged
                  return 
              else: 

                  self.message_port_pub(
                      pmt.intern("out"),
                      pmt.cons(meta, data)
                  )
              # else: drop silently
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr

      class pdu_ax25_byte_prepender_filter(gr.basic_block):
          """
          pass PDUs only if second byte == 0xA2
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_second_byte_filter",
                  in_sig=None,
                  out_sig=None
              )

              # Message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return

              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  return

              vec = pmt.u8vector_elements(data)

              if len(vec) < 2:
                  return

              # DROP if second byte is 0xFE
              if vec[1] != 0xA2:
                  return

              # PREPEND 0x00 safely
              new_vec = [0x00] + list(vec)

              new_pmt = pmt.init_u8vector(len(new_vec), new_vec)

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(meta, new_pmt)
              )
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: freq_deviation*5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate // Decimation
    type: ccc
    width: 1e3
    win: window.WIN_RECTANGULAR
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rx_offset
    decim: Decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*Decimation), 1000)
    type: ccc
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"FSK Demod Output"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Symbol Sync Output"'
    size: '1024'
    srate: baud_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"X-Lating FIR output"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Low Pass output"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Noise and stuff"'
    type: complex
  states: {}
- name: satellites_ax25_deframer_1
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_endurosat_deframer_1_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 435e6
    freq_correction: frequency_correction
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2_1_0_1, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax25_deframer_1, '0']
- [digital_symbol_sync_xx_0, '0', satellites_endurosat_deframer_1_0, '0']
- [epy_block_0, out, network_socket_pdu_0_1, pdus]
- [epy_block_1, out, network_socket_pdu_0_1, pdus]
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [satellites_ax25_deframer_1, out, blocks_message_debug_0, print]
- [satellites_ax25_deframer_1, out, epy_block_1, in]
- [satellites_endurosat_deframer_1_0, out, blocks_message_debug_0_0, print]
- [satellites_endurosat_deframer_1_0, out, epy_block_0, in]
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
