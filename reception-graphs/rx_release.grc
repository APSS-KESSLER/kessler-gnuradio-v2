options:
  parameters:
    generate_options: qt_gui
    id: rx_new
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud_rate) / 2
  states: {}
- name: frequency_correction
  id: variable_qtgui_range
  parameters:
    label: frequency correction
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate//Decimation)/(2*math.pi*freq_deviation)
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.1'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: ((samp_rate // Decimation) // baud_rate)
    ted_gain: '0.1'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: freq_deviation*5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate // Decimation
    type: ccc
    width: 1e3
    win: window.WIN_RECTANGULAR
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rx_offset
    decim: Decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*Decimation), 1000)
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"FSK Demod Output"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbol Sync Output"'
    size: '1024'
    srate: baud_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"X-Lating FIR output"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Low Pass output"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Mod Output"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Noise and stuff"'
    type: complex
  states: {}
- name: satellites_endurosat_deframer_1_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    freq_correction: freq_deviation
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2_1_0_1, '0']
- [digital_symbol_sync_xx_0, '0', satellites_endurosat_deframer_1_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [gpredict_doppler_0, state, blocks_message_debug_0, log]
- [satellites_endurosat_deframer_1_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_endurosat_deframer_1_0, out, network_socket_pdu_0_1, pdus]
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
