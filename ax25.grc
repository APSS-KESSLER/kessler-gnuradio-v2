options:
  parameters:
    generate_options: qt_gui
    id: Ax25-rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: DL_Freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bt
  id: variable
  parameters:
    value: 2*freq_deviation/baud_rate
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud_rate) / 2
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_0_0
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_0_1
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * freq_deviation) / samp_rate
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: float
  states: {state: disabled}
- name: baud_rate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 48e3
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/flat-sat-workbench/orb-ops/satellite-recordings/us01.wav
    repeat: 'True'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: afterDemod
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: afterDemod
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: rx_offset
  id: parameter
  parameters:
    comment: |-
      RF configuration of Si4464 via hex strings
      is suboptimal. 
      Resultant frequency is -1.7kHz offset
    label: RX Offset [Hz]
    type: eng_float
    value: '1000'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_endurosat_deframer_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud
    iq: 'True'
    options: '"--deviation 2400 --use_agc"'
    samp_rate: baud*2
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    samp_rate: 48e3
    subaudio: 'False'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 435e6
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', satellites_fsk_demodulator_0_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', qtgui_waterfall_sink_x_2, '0']
- [analog_pwr_squelch_xx_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [blocks_throttle2_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_throttle2_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_descrambler_bb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_endurosat_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_endurosat_deframer_0, out, network_socket_pdu_0, pdus]
- [satellites_fsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_fsk_demodulator_0, '0', qtgui_waterfall_sink_x_1, '0']
- [satellites_fsk_demodulator_0, '0', satellites_endurosat_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_fsk_demodulator_0_0, '0', qtgui_time_sink_x_1, '0']
- [satellites_fsk_demodulator_0_0, '0', qtgui_waterfall_sink_x_2_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_2, '0']
- [soapy_rtlsdr_source_0, '0', satellites_fsk_demodulator_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
