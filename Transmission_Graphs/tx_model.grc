options:
  parameters:
    author: Orb Ops APSS
    generate_options: qt_gui
    id: transmission_prototype
    output_language: python
    title: Tx
  states: {}

blocks:
- name: OBC_RX_PORT
  id: variable
  parameters:
    value: '2003'
  states: {}
- name: OBC_TX_PORT
  id: variable
  parameters:
    value: '2002'
  states: {}
- name: RX_GS_PORT
  id: variable
  parameters:
    value: '2001'
  states: {}
- name: TX_GS_PORT
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud_rate) / 2
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: num_preamble_aa
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * freq_deviation) / samp_rate
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Lenovo\Downloads\debug3.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Lenovo\Downloads\debug3.txt
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {state: disabled}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0005'
    freq_offset: '0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0005'
    freq_offset: '0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: int(samp_rate // baud_rate)
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: int(samp_rate // baud_rate)
    sensitivity: sensitivity
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud_rate
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud_rate
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: '"127.0.0.2"'
    mtu: '10000'
    port: '2000'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1200'
    port: '2002'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: '"127.0.0.2"'
    mtu: '10000'
    port: '2001'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_BALK
    type: byte
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_BALK
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    name: '"RAW RF INPUT"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    name: '"Demod"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    name: '"Demod"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    name: '"RAW RF INPUT"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    name: '"FINAL"'
    type: msg_float
  states: {}
- name: qtgui_waterfall_sink_x_2_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    name: '"FINAL"'
    type: msg_float
  states: {}
- name: satellites_endurosat_deframer_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {}
- name: satellites_endurosat_deframer_0_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    options: '"--deviation 2400 --use_agc"'
    samp_rate: baud_rate*2
    subaudio: 'False'
  states: {}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    options: '"--deviation 2400 --use_agc"'
    samp_rate: baud_rate*2
    subaudio: 'False'
  states: {}

connections:
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle2_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_uchar_to_float_0, '0', satellites_endurosat_deframer_0, '0']
- [blocks_uchar_to_float_0_0, '0', satellites_endurosat_deframer_0_0, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0, '0']
- [channels_channel_model_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [channels_channel_model_0_0, '0', blocks_throttle2_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gfsk_demod_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_gfsk_mod_0, '0', channels_channel_model_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gfsk_mod_0_0, '0', channels_channel_model_0_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [network_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [network_socket_pdu_0_0_0, pdus, blocks_message_debug_0_1, print_pdu]
- [network_socket_pdu_0_0_0, pdus, pdu_pdu_to_stream_x_0_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', digital_gfsk_mod_0, '0']
- [pdu_pdu_to_stream_x_0_0, '0', digital_gfsk_mod_0_0, '0']
- [satellites_endurosat_deframer_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_endurosat_deframer_0, out, network_socket_pdu_0_1, pdus]
- [satellites_endurosat_deframer_0, out, qtgui_waterfall_sink_x_2, in]
- [satellites_endurosat_deframer_0_0, out, blocks_message_debug_0_0_0, print_pdu]
- [satellites_endurosat_deframer_0_0, out, network_socket_pdu_1, pdus]
- [satellites_endurosat_deframer_0_0, out, qtgui_waterfall_sink_x_2_0, in]
- [satellites_fsk_demodulator_0, '0', blocks_float_to_uchar_0, '0']
- [satellites_fsk_demodulator_0, '0', blocks_uchar_to_float_0, '0']
- [satellites_fsk_demodulator_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_endurosat_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', blocks_float_to_uchar_0_0, '0']
- [satellites_fsk_demodulator_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [satellites_fsk_demodulator_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_endurosat_deframer_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
