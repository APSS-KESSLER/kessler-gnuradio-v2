options:
  parameters:
    author: flat-sat-workbench
    generate_options: qt_gui
    id: tx_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud) / 2
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: num_preamble_aa
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * freq_deviation) / samp_rate
  states: {}
- name: baud
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Lenovo\Downloads\debug3.txt
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_demod_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_demod_2
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_demod_3
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: int(samp_rate // baud)
    sensitivity: sensitivity
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '2003'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.2
    mtu: '10000'
    port: '2000'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_BALK
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '1024'
    name: '"RAW RF INPUT"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    name: '"FINAL"'
    type: msg_float
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_endurosat_deframer_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud
    iq: 'True'
    options: '"--deviation 2400 --use_agc"'
    samp_rate: baud*2
    subaudio: 'False'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 435e6
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_1
  id: soapy_hackrf_source
  parameters:
    center_freq: '435'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 435E6
    freq_correction: '97.5'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', satellites_endurosat_deframer_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gfsk_demod_2, '0', satellites_endurosat_deframer_0, '0']
- [digital_gfsk_demod_2, '0', satellites_fsk_demodulator_0, '0']
- [digital_gfsk_demod_3, '0', blocks_message_debug_0_0, log]
- [digital_gfsk_demod_3, '0', blocks_message_debug_0_0, print]
- [digital_gfsk_demod_3, '0', network_socket_pdu_0, pdus]
- [digital_gfsk_demod_3, '0', qtgui_waterfall_sink_x_2, in]
- [digital_gfsk_demod_3, '0', satellites_endurosat_deframer_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', soapy_hackrf_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_2, '0']
- [digital_symbol_sync_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [network_socket_pdu_0_0, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_0_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', digital_gfsk_mod_0, '0']
- [satellites_ax25_deframer_0, out, network_socket_pdu_0, pdus]
- [satellites_ax25_deframer_0, out, qtgui_waterfall_sink_x_2, in]
- [satellites_endurosat_deframer_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_endurosat_deframer_0, out, network_socket_pdu_0, pdus]
- [satellites_endurosat_deframer_0, out, qtgui_waterfall_sink_x_2, in]
- [satellites_fsk_demodulator_0, '0', blocks_float_to_uchar_0, '0']
- [satellites_fsk_demodulator_0, '0', blocks_uchar_to_float_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_endurosat_deframer_0, '0']
- [soapy_hackrf_source_1, '0', digital_gfsk_demod_3, '0']
- [soapy_hackrf_source_1, '0', digital_symbol_sync_xx_0, '0']
- [soapy_hackrf_source_1, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
