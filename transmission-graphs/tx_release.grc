options:
  parameters:
    generate_options: qt_gui
    id: tx_new
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud_rate) / 2
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * freq_deviation) / samp_rate
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: int(samp_rate // baud_rate)
    sensitivity: sensitivity
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: '"127.0.0.2"'
    mtu: '10000'
    port: '2000'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_BALK
    type: byte
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [digital_gfsk_mod_0, '0', soapy_hackrf_sink_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [network_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
