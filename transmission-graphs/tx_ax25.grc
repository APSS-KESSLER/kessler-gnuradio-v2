options:
  parameters:
    author: Orb Ops APSS
    generate_options: qt_gui
    id: transmission_prototype
    output_language: python
    title: Tx
  states: {}

blocks:
- name: freq_deviation
  id: variable
  parameters:
    value: (mod_index * baud_rate) / 2
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: num_preamble_aa
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * freq_deviation) / samp_rate
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_hdlc_framer_pb_0
  id: digital_hdlc_framer_pb
  parameters:
    frame_tag_name: '1'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.2
    mtu: '10000'
    port: '2000'
    type: UDP_SERVER
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 436e6
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {}

connections:
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', soapy_hackrf_sink_0, '0']
- [digital_hdlc_framer_pb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_hdlc_framer_pb_0, '0', satellites_nrzi_encode_0, '0']
- [digital_scrambler_bb_0, '0', digital_gfsk_mod_0, '0']
- [network_socket_pdu_0_0, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_0_0, pdus, digital_hdlc_framer_pb_0, in]
- [satellites_nrzi_encode_0, '0', digital_scrambler_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
